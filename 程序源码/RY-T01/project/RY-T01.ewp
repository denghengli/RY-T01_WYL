# IAR project RY-T01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RE ST STM32F103RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F103xE; IAR_ARM_CM3; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\app; ..\driver; ..\hal\CMSIS\Include; ..\os\include; ..\os; ..\hal\STM32F1xx_HAL_Driver; ..\hal\STM32F1xx_HAL_Driver\Inc; ..\hal; ..\os\portable; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..\os\CMSIS_RTOS; ..\hal\CMSIS\Device\ST\STM32F1xx\Include; ..\modbus; ..\driver\lcd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\os\include
  OBJCOPY.OOCOutputFile: RY-T01.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group app
    ../app/: app_ad.c app_atppress.c app_comm.c app_da.c app_gaspress.c app_gui.c app_gui.h app_humit.c app_pt100.c app_speedcal.c app_timing.c app_wdt.c common.c main.c mb_cmd_proc.c systemdata.c
    ../hal/: stm32f1xx_it.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group driver
    ../driver/: bsp_mcp7428.c bsp_zxp8.c bsp_zxp8.h drv_adc.c drv_flash.c drv_gpio.c drv_i2c.c drv_soft_i2c.c drv_soft_timer.c drv_spi.c drv_task.c drv_timer.c drv_uart.c
  group driver/lcd
    ../driver/lcd/: drv_lcd.c drv_lcd.h font_ascii.h font_gb.h hal_lcd.c hal_lcd.h pic.h
  group gui
    ../gui/: ui_blowfreq_set.c ui_flow_adjust.c ui_fun_isclean.c ui_fun_isrefresh.c ui_handle_blow.c ui_main_wind.c ui_meu_wind.c ui_paraset.c ui_paraset_auto_calibzero.c ui_paraset_blowinter.c ui_paraset_humit_aocomp.c ui_paraset_humit_cancelzero.c ui_paraset_humit_sensortype.c ui_paraset_humit_unitselect.c ui_paraset_humit_zerocalib.c ui_paraset_pitgk.c ui_paraset_press_aocomp.c ui_paraset_speed_aocomp.c ui_paraset_speedk.c ui_paraset_tem_aocomp.c ui_password_login.c ui_restore_factory.c ui_sectionarea_set.c ui_smoothtime_set.c
  group hal
    ../hal/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xe.s
    ../hal/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_ll_adc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c
    ../hal/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group modbus
    ../modbus/: modbus.c modbus_master.c modbus_slave.c
  group os
    ../os/CMSIS_RTOS/: cmsis_os.c
    ../os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/portable/MemMang/: heap_2.c
    ../os/portable/: port.c portasm.s
